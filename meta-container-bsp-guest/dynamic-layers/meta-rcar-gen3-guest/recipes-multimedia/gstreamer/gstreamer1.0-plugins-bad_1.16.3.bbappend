DEPENDS:remove = "linux-renesas"

EXTRA_OECONF:remove = "--enable-kms"
PACKAGECONFIG:remove = "kms"
