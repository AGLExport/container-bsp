RRECOMMENDS_${PN}_remove = " \
                      kernel-module-autofs4 kernel-module-unix kernel-module-ipv6 kernel-module-sch-fq-codel \
"
